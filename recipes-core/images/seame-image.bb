SUMMARY = "SEA:ME image"
LICENSE = "CLOSED"

inherit seame_image
